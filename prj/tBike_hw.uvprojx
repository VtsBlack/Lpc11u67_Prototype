# Keil uVision project tBike_hw.uvprojx, settings and files
target tBike (ARM-ADS)
  device: LPC11U67 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10003FFF) IRAM2(0x20000000-0x200007FF) IROM(0x0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0+")
  output: tBike_hw +hex
  c flags: Optim=1
  c define: CORE_M0PLUS, NO_BOARD_LIB
  c include: ..\lpcopen_2_06_keil_iar_manley_11u68\software\lpc_core\lpc_chip\chip_common;..\lpcopen_2_06_keil_iar_manley_11u68\software\CMSIS\CMSIS\Include;..\lpcopen_2_06_keil_iar_manley_11u68\software\lpc_core\lpc_chip\chip_11u6x;..\lpcopen_2_06_keil_iar_manley_11u68\software\lpc_core\lpc_chip\chip_11u6x\config_11U6X;..\lpcopen_2_06_keil_iar_manley_11u68\software\lpc_core\lpc_board\boards_11u6x\manley_11u68;..\lpcopen_2_06_keil_iar_manley_11u68\software\lpc_core\lpc_board\board_common
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x4000
  memory RVCT10: RAM 0x20000000 size 0x800
  group Startup
    ../lpcopen_2_06_keil_iar_manley_11u68/applications/lpc11u6x/startup_code/: keil_startup_lpc11u6x.s sysinit.c
  group main
    ../source/: main.c
  group LPC OPEN
    ../lpcopen_2_06_keil_iar_manley_11u68/software/lpc_core/lpc_chip/chip_11u6x/: gpio_11u6x.c uart_0_11u6x.c clock_11u6x.c iocon_11u6x.c chip_11u6x.c syscon_11u6x.c sysinit_11u6x.c
    ../lpcopen_2_06_keil_iar_manley_11u68/software/lpc_core/lpc_chip/chip_common/: ring_buffer.c
  group ::CMSIS
    C:/Develop/ARM/PACK/ARM/CMSIS/4.2.0/CMSIS_RTX/LIB/ARM/: RTX_CM0.lib
    RTE/CMSIS/: RTX_Conf_CM.c
software components: CMSIS:RTOS:Keil RTX 4.75.0
