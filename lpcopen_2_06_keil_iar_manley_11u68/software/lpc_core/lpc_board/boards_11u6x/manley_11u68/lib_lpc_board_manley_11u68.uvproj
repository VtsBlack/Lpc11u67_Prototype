# Keil uVision project lib_lpc_board_manley_11u68.uvproj, settings and files
target manley_11u68 (ARM-ADS)
  device: LPC11U37/501 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: board_manley_11u68 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0PLUS
  c include: ..\..\..\..\CMSIS;..\..\..\lpc_chip\chip_11u6x;..\..\..\lpc_chip\chip_11u6x\config_11u6x;..\..\..\lpc_chip\chip_common;..\manley_11u68;..\..\board_common
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  group board_manley_11u68
    ./: board.c board_sysinit.c board_lcd.c
