# Keil uVision project tBike_hw.uvproj, settings and files
target tBike (ARM-ADS)
  device: LPC11U67 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10003FFF) IRAM2(0x20000000-0x200007FF) IROM(0x0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0+")
  output: tBike_hw
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x4000
  memory RVCT10: RAM 0x20000000 size 0x800
  group Startup
    ./: startup_LPC11U6x.s
  group main
    ../source/: main.c
  group core
    ../lpc1100/: core_cm0.c system_LPC11Uxx.c
